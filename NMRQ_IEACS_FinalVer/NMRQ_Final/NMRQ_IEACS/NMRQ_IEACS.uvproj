# Keil uVision project NMRQ_IEACS.uvproj, settings and files
target NMRQ_IEACS (ARM-ADS)
  device: LPC2103 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: debug_in_rom +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  scatter file: .\Source\mem_c.scf
  group StartUp
    ./: Startup.s
  group ARM
    ./ARM/: Os_cpu_a.s Os_cpu_c.c
  group UcosII
    ./UcosII/: OS_CORE.C OS_TASK.C OS_TIME.C uCOS_II.H
  group Source
    ./Source/: helper.c main.c NMRQ_key.c NMRQ_eac.c NMRQ_hi.c NMRQ_com.c NMRQ_task.c
  group Target
    ./Target/: Target.c IRQ.s
    ./Include/: IRQ.inc
  group Driver
    ./Driver/: NMRQ_lcd240160.c
